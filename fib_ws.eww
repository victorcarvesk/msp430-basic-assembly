<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\fibonacci\fibonacci.ewp</path>
    </project>
    <batchBuild />
</workspace>
